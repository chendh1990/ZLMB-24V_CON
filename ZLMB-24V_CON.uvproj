# Keil uVision project ZLMB-24V_CON.uvproj, settings and files
target ZLMB-24V_CON (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: MotorCtr +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\Bsp
  group Bsp
    ./Bsp/: Timer.c Uart.c Key.c Led.c
  group Source
    ./Source/: Interrupt.c Main.c Sys.c TimerUnit.c QMsg.c PacketQueue.c Common.c Wifi.c Peripheral.c
  group ThirdParty
    ./Source/ThirdParty/Tuya/mcu_sdk/: mcu_api.c protocol.c system.c
  group Startup
    ./Startup/: STARTUP.A51
